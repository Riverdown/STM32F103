# Keil uVision project feng_led.uvprojx, settings and files
target led_c (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: feng_led +hex
  AfterMake: fromelf  --bin  --output=feng_led.bin  Objects\feng_led.axf
  AfterMake: fromelf  --text  -a -c  --output=feng_led.dis  Objects\feng_led.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\feng_led.sct
  group main
    ./: main.c
  group cpu
    ./: start.s
  group uart
    ./: uart_bsp.c
  group string
    ./: string.c
